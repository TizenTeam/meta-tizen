SECTION = "Multimedia/Utilities"
SRPM_IS_LIB = "libv4l"

SECTION = "Graphics & UI Framework/Libraries"

# Split out libs, as done traditionally in Tizen.
inherit libpkg

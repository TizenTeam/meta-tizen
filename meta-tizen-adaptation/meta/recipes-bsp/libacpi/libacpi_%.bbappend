SECTION = "System/Hardware Adaptation"
SRPM_IS_LIB = "${PN}"

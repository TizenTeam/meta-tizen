SECTION = "Network & Connectivity/Bluetooth"
SRPM_IS_LIB = "${PN}"

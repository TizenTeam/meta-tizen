SECTION = "Base/Libraries"
# TODO: SRPM_IS_LIB = "${PN}" currently fails because of two post sections

SECTION = "Security/Crypto Libraries"
SRPM_IS_LIB = "libcrypto libssl"

SECTION = "Base/Utilities"

DEPENDS += "smack"

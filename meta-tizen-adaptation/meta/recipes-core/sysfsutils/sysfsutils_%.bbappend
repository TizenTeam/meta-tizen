SECTION = "System/Libraries"
SRPM_IS_LIB = "libsysfs"

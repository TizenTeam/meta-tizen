SECTION = "Development/Toolchain"

# Compile without lttng-ust, even on architectures where it could be
# used.
LTTNGUST = ""

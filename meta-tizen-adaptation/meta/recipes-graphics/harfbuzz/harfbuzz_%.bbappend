SECTION = "Graphics/Font Management"
SRPM_IS_LIB = "lib${PN}"

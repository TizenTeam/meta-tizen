SECTION = "System/Other"
SRPM_IS_LIB = "lib${PN}"

# TODO: replicate and/or copy the postinst_prologue() which calls
# pango-querymodules to create /etc/pango/pango.modules.

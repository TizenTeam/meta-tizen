SECTION = "Multimedia/Audio"
SRPM_IS_LIB = "lib${PN} lib${PN}++"

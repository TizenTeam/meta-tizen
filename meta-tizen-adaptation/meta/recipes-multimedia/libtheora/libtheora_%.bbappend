SECTION = "Multimedia/Video"
SRPM_IS_LIB = "${PN}"

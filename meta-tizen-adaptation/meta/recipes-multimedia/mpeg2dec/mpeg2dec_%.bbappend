SECTION = "Multimedia/Video"
SRPM_IS_LIB = "libmpeg2 libmpeg2convert"

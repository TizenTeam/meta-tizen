SECTION = "System/Libraries"
SRPM_IS_LIB = "${PN}-compat lib${PN}"

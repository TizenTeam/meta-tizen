SECTION = "Network & Connectivity/Libraries"
SRPM_IS_LIB = "${PN} ${PN}-cli ${PN}-genl ${PN}-idiag ${PN}-nf ${PN}-route"

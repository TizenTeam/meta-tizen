# Not used in Tizen IVI 3.0.
RDEPENDS_${PN}_remove = "wrt-widgets"

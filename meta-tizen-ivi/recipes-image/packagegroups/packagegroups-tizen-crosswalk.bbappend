# Not used in Tizen IVI 3.0.
RDEPENDS_packagegroup-tizen-crosswalk_remove = "wrt-widgets"
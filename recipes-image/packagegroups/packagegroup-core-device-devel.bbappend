RDEPENDS_packagegroup-core-device-devel_remove = "oprofileui-server"
